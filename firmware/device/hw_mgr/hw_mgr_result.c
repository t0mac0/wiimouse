/*!
 * \file hw_result.c
 *
 * \brief 
 *
 *
 * \date Mar 4, 2011
 * \author Dan Riedler
 *
 */

/*-----------------------------------------------------------------------------
 Includes
------------------------------------------------------------------------------*/
#include "hw_mgr_result.h"

/*-----------------------------------------------------------------------------
 Defines
------------------------------------------------------------------------------*/

/*-----------------------------------------------------------------------------
 Macros
------------------------------------------------------------------------------*/

/*-----------------------------------------------------------------------------
 Typedefs
------------------------------------------------------------------------------*/

/*-----------------------------------------------------------------------------
 Local Function Prototypes
------------------------------------------------------------------------------*/

/*-----------------------------------------------------------------------------
 Data Members
------------------------------------------------------------------------------*/


//*****************************************************************************
//
// Exported Functions
//
//*****************************************************************************

/******************************************************************************/
CString HW_MGR_GetResultCodeStr(Result result)
{
   CString str;

   if( RESULT_MODULE_ID(result) == MOD_MGR_HW_MGR )
   {
       uint32 subModId = RESULT_SUB_MODULE_ID(result);

       if( subModId == RESULT_NULL_MOD )
       {
           switch(RESULT_CODE(result))
           {
           default:
               str = "result code undefined!";
           }
       }
       else
       {
           switch(subModId)
           {
#ifdef HW_MOD_USART
           case HW_MGR_USART:
#endif
#if( HW_MGR_MODULE_COUNT > 0 )
               str = hwMgrModules[subModId].GetResutCodeStr(result);
#endif
           default:
               str = "sub-module undefined!";
           }
       }
   }
   else
   {
       // module has been improperly setup
       ASSERT(0);
   }


   return str;
}



//*****************************************************************************
//
// Local Functions
//
//*****************************************************************************

